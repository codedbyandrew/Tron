# Keil uVision project Lab9.uvprojx, settings and files
target blinky (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LM3S1968 Texas Instruments
  pack: Keil.LM3S_DFP.1.1.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Blinky
  AfterMake: fromelf --bin --output .\rvmdk\blinky.bin .\rvmdk\blinky.axf
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM3S1968
  c include: ..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: blinky.sct
  link misc: --entry Reset_Handler
  group Source
    ./: startup_rvmdk.S Lab9.c
  group Libraries
    ./: driverlib-cm3.lib ECE210.lib
software components: CMSIS:CORE 4.3.0
